# Repository jiekebo/NTC-6251

File README.md:

QMK / VIA compatible replacement PCB for NTC-KB6252
===================================================

## KiCad design pcb/ntc-6251-qmk-pcb.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D75, D76, D77, D78, D79, D80, D81, D82, D83, D84, D85, D86, D87, D88, D89, D90, D91, D92, D93, D94, D95, D97, D98, D99, D100, D101, D102, D103: D_Small; D_DO-35_SOD27_P7.62mm_Horizontal
D96, D104, D105: LED; LED_Rectangular_W5.0mm_H2.0mm
J1: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Horizontal
MX1, MX2, MX3, MX4, MX5, MX6, MX7, MX8, MX9, MX10, MX11, MX12, MX13, MX14, MX15, MX16, MX17, MX18, MX19, MX20, MX21, MX22, MX23, MX24, MX25, MX26, MX27, MX28, MX29, MX30, MX31, MX32, MX33, MX34, MX35, MX36, MX37, MX38, MX39, MX40, MX41, MX42, MX43, MX44, MX45, MX46, MX47, MX48, MX49, MX50, MX51, MX52, MX53, MX54, MX55, MX56, MX57, MX58, MX59, MX60, MX61, MX62, MX63, MX64, MX65, MX66, MX67, MX68, MX69, MX70, MX71, MX72, MX73, MX74, MX75, MX76, MX77, MX78, MX79, MX80, MX81, MX82, MX83, MX84, MX85, MX86, MX87, MX88, MX89, MX90, MX91, MX92, MX93, MX94, MX95, MX97, MX98, MX99, MX100, MX101, MX102, MX103: MX-NoLED; ALPS-1U
R1, R2, R3: R_Small; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U1: YAAJ_WeAct_BlackPill_Part_Like_SWD_Breakout; YAAJ_WeAct_BlackPill_SWD_2

Connections:
+3V3: D96.2 (A), D104.2 (A), D105.2 (A), U1.38 (3V3)
+5V: J1.4, U1.40 (5V)
CAPS_LOCK: R2.2, U1.36 (PB2)
Col1: MX1.1 (COL), MX6.1 (COL), MX21.1 (COL), MX23.1 (COL), MX24.1 (COL), MX25.1 (COL), MX29.1 (COL), MX102.1 (COL), U1.12 (PB4)
Col2: MX2.1 (COL), MX13.1 (COL), MX18.1 (COL), MX28.1 (COL), MX30.1 (COL), MX36.1 (COL), MX94.1 (COL), U1.13 (PB5)
Col3: MX3.1 (COL), MX11.1 (COL), MX20.1 (COL), MX31.1 (COL), MX35.1 (COL), MX37.1 (COL), MX44.1 (COL), MX86.1 (COL), U1.14 (PB6)
Col4: MX4.1 (COL), MX27.1 (COL), MX43.1 (COL), MX45.1 (COL), MX52.1 (COL), MX55.1 (COL), MX78.1 (COL), MX80.1 (COL), U1.15 (PB7)
Col5: MX5.1 (COL), MX34.1 (COL), MX47.1 (COL), MX51.1 (COL), MX53.1 (COL), MX60.1 (COL), MX70.1 (COL), MX88.1 (COL), U1.16 (PB8)
Col6: MX32.1 (COL), MX41.1 (COL), MX42.1 (COL), MX59.1 (COL), MX61.1 (COL), MX62.1 (COL), MX68.1 (COL), MX72.1 (COL), U1.17 (PB9)
Col8: MX14.1 (COL), MX38.1 (COL), MX57.1 (COL), MX58.1 (COL), MX75.1 (COL), MX77.1 (COL), MX84.1 (COL), MX87.1 (COL), U1.22 (PC13)
Col9: MX26.1 (COL), MX48.1 (COL), MX65.1 (COL), MX66.1 (COL), MX83.1 (COL), MX85.1 (COL), MX92.1 (COL), MX95.1 (COL), U1.23 (PC14)
Col10: MX33.1 (COL), MX56.1 (COL), MX73.1 (COL), MX74.1 (COL), MX91.1 (COL), MX93.1 (COL), MX100.1 (COL), MX103.1 (COL), U1.24 (PC15)
Col12: MX8.1 (COL), MX10.1 (COL), MX16.1 (COL), MX46.1 (COL), MX63.1 (COL), MX89.1 (COL), MX90.1 (COL), U1.26 (PA0)
Col13: MX15.1 (COL), MX17.1 (COL), MX22.1 (COL), MX54.1 (COL), MX71.1 (COL), MX79.1 (COL), MX97.1 (COL), MX98.1 (COL), U1.27 (PA1)
D+: J1.2, U1.9 (PA12)
D-: J1.3, U1.8 (PA11)
GND: J1.1, U1.39 (GND)
NUM_LOCK: R1.2, U1.37 (PB10)
unnamed: D1.2 (A), MX1.2 (ROW)
unnamed: D2.2 (A), MX2.2 (ROW)
unnamed: D3.2 (A), MX3.2 (ROW)
unnamed: D4.2 (A), MX4.2 (ROW)
unnamed: D5.2 (A), MX5.2 (ROW)
unnamed: D6.2 (A), MX6.2 (ROW)
unnamed: D7.2 (A), MX7.2 (ROW)
unnamed: D8.2 (A), MX8.2 (ROW)
unnamed: D9.2 (A), MX9.2 (ROW)
unnamed: D10.2 (A), MX10.2 (ROW)
unnamed: D11.2 (A), MX11.2 (ROW)
unnamed: D12.2 (A), MX12.2 (ROW)
unnamed: D13.2 (A), MX13.2 (ROW)
unnamed: D14.2 (A), MX14.2 (ROW)
unnamed: D15.2 (A), MX15.2 (ROW)
unnamed: D16.2 (A), MX16.2 (ROW)
unnamed: D17.2 (A), MX17.2 (ROW)
unnamed: D18.2 (A), MX18.2 (ROW)
unnamed: D19.2 (A), MX19.2 (ROW)
unnamed: D20.2 (A), MX20.2 (ROW)
unnamed: D21.2 (A), MX21.2 (ROW)
unnamed: D22.2 (A), MX22.2 (ROW)
unnamed: D23.2 (A), MX23.2 (ROW)
unnamed: D24.2 (A), MX24.2 (ROW)
unnamed: D25.2 (A), MX25.2 (ROW)
unnamed: D26.2 (A), MX26.2 (ROW)
unnamed: D27.2 (A), MX27.2 (ROW)
unnamed: D28.2 (A), MX28.2 (ROW)
unnamed: D29.2 (A), MX29.2 (ROW)
unnamed: D30.2 (A), MX30.2 (ROW)
unnamed: D31.2 (A), MX31.2 (ROW)
unnamed: D32.2 (A), MX32.2 (ROW)
unnamed: D33.2 (A), MX33.2 (ROW)
unnamed: D34.2 (A), MX34.2 (ROW)
unnamed: D35.2 (A), MX35.2 (ROW)
unnamed: D36.2 (A), MX36.2 (ROW)
unnamed: D37.2 (A), MX37.2 (ROW)
unnamed: D38.2 (A), MX38.2 (ROW)
unnamed: D39.2 (A), MX39.2 (ROW)
unnamed: D40.2 (A), MX40.2 (ROW)
unnamed: D41.2 (A), MX41.2 (ROW)
unnamed: D42.2 (A), MX42.2 (ROW)
unnamed: D43.2 (A), MX43.2 (ROW)
unnamed: D44.2 (A), MX44.2 (ROW)
unnamed: D45.2 (A), MX45.2 (ROW)
unnamed: D46.2 (A), MX46.2 (ROW)
unnamed: D47.2 (A), MX47.2 (ROW)
unnamed: D48.2 (A), MX48.2 (ROW)
unnamed: D49.2 (A), MX49.2 (ROW)
unnamed: D50.2 (A), MX50.2 (ROW)
unnamed: D51.2 (A), MX51.2 (ROW)
unnamed: D52.2 (A), MX52.2 (ROW)
unnamed: D53.2 (A), MX53.2 (ROW)
unnamed: D54.2 (A), MX54.2 (ROW)
unnamed: D55.2 (A), MX55.2 (ROW)
unnamed: D56.2 (A), MX56.2 (ROW)
unnamed: D57.2 (A), MX57.2 (ROW)
unnamed: D58.2 (A), MX58.2 (ROW)
unnamed: D59.2 (A), MX59.2 (ROW)
unnamed: D60.2 (A), MX60.2 (ROW)
unnamed: D61.2 (A), MX61.2 (ROW)
unnamed: D62.2 (A), MX62.2 (ROW)
unnamed: D63.2 (A), MX63.2 (ROW)
unnamed: D64.2 (A), MX64.2 (ROW)
unnamed: D65.2 (A), MX65.2 (ROW)
unnamed: D66.2 (A), MX66.2 (ROW)
unnamed: D67.2 (A), MX67.2 (ROW)
unnamed: D68.2 (A), MX68.2 (ROW)
unnamed: D69.2 (A), MX69.2 (ROW)
unnamed: D70.2 (A), MX70.2 (ROW)
unnamed: D71.2 (A), MX71.2 (ROW)
unnamed: D72.2 (A), MX72.2 (ROW)
unnamed: D73.2 (A), MX73.2 (ROW)
unnamed: D74.2 (A), MX74.2 (ROW)
unnamed: D75.2 (A), MX75.2 (ROW)
unnamed: D76.2 (A), MX76.2 (ROW)
unnamed: D77.2 (A), MX77.2 (ROW)
unnamed: D78.2 (A), MX78.2 (ROW)
unnamed: D79.2 (A), MX79.2 (ROW)
unnamed: D80.2 (A), MX80.2 (ROW)
unnamed: D81.2 (A), MX81.2 (ROW)
unnamed: D82.2 (A), MX82.2 (ROW)
unnamed: D83.2 (A), MX83.2 (ROW)
unnamed: D84.2 (A), MX84.2 (ROW)
unnamed: D85.2 (A), MX85.2 (ROW)
unnamed: D86.2 (A), MX86.2 (ROW)
unnamed: D87.2 (A), MX87.2 (ROW)
unnamed: D88.2 (A), MX88.2 (ROW)
unnamed: D89.2 (A), MX89.2 (ROW)
unnamed: D90.2 (A), MX90.2 (ROW)
unnamed: D91.2 (A), MX91.2 (ROW)
unnamed: D92.2 (A), MX92.2 (ROW)
unnamed: D93.2 (A), MX93.2 (ROW)
unnamed: D94.2 (A), MX94.2 (ROW)
unnamed: D95.2 (A), MX95.2 (ROW)
unnamed: D96.1 (K), R1.1
unnamed: D97.2 (A), MX97.2 (ROW)
unnamed: D98.2 (A), MX98.2 (ROW)
unnamed: D99.2 (A), MX99.2 (ROW)
unnamed: D100.2 (A), MX100.2 (ROW)
unnamed: D101.2 (A), MX101.2 (ROW)
unnamed: D102.2 (A), MX102.2 (ROW)
unnamed: D103.2 (A), MX103.2 (ROW)
unnamed: D104.1 (K), R2.1
unnamed: D105.1 (K), R3.1
Row1: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D41.1 (K), D49.1 (K), D57.1 (K), D65.1 (K), D73.1 (K), D81.1 (K), D89.1 (K), D97.1 (K), U1.29 (PA3)
Row2: D6.1 (K), D13.1 (K), D20.1 (K), D27.1 (K), D34.1 (K), D42.1 (K), D50.1 (K), D58.1 (K), D66.1 (K), D74.1 (K), D82.1 (K), D90.1 (K), D98.1 (K), U1.30 (PA4)
Row3: D8.1 (K), D15.1 (K), D21.1 (K), D28.1 (K), D35.1 (K), D43.1 (K), D51.1 (K), D59.1 (K), D67.1 (K), D75.1 (K), D83.1 (K), D91.1 (K), D99.1 (K), U1.31 (PA5)
Row4: D9.1 (K), D16.1 (K), D22.1 (K), D29.1 (K), D36.1 (K), D44.1 (K), D52.1 (K), D60.1 (K), D68.1 (K), D76.1 (K), D84.1 (K), D92.1 (K), D100.1 (K), U1.32 (PA6)
Row5: D10.1 (K), D17.1 (K), D23.1 (K), D30.1 (K), D37.1 (K), D45.1 (K), D53.1 (K), D61.1 (K), D69.1 (K), D77.1 (K), D85.1 (K), D93.1 (K), D101.1 (K), U1.33 (PA7)
Row6: D24.1 (K), D31.1 (K), D32.1 (K), D38.1 (K), D39.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), D54.1 (K), D55.1 (K), D56.1 (K), D64.1 (K), U1.34 (PB0)
Row7: D7.1 (K), D12.1 (K), D14.1 (K), D62.1 (K), D63.1 (K), D70.1 (K), D71.1 (K), D78.1 (K), D86.1 (K), D94.1 (K), D95.1 (K), D102.1 (K), D103.1 (K), U1.11 (PB3)
Row8: D11.1 (K), D18.1 (K), D19.1 (K), D25.1 (K), D26.1 (K), D33.1 (K), D40.1 (K), D72.1 (K), D79.1 (K), D80.1 (K), D87.1 (K), D88.1 (K), U1.10 (PA15)
SCROLL_LOCK: R3.2, U1.35 (PB1)

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
Board: 2 copper layers, 432.0 x 109.1 mm, 212 parts (0 on the bottom side), 134 nets.

## Commit log

2021-10-02 Added component libraries
2021-10-02 Added alps switch 3d model
2021-10-03 Finished schematic grid, connected footprints, prelim. arrangement of components on pcb
2021-12-12 Finished aligning switches and diodes
2021-12-15 Better matrix layout
2021-12-21 Updated layout
2021-12-21 Small fixes to rounded pcb
2021-12-25 Finished most of small issues with traces
2021-12-25 Created lib for logo
2021-12-28 Changed connector fixed controller pins, re-routed all traces near controller
2021-12-29 Last fixes and copper pour on rounded pcb
2021-12-29 Last small fixes before printing
2021-12-29 Output file added to project
2022-01-01 Cleanup
2022-01-01 Initial readme files
2022-01-01 Added render of pcb
2022-01-01 Readme update
2022-01-02 Switched place for schematic column 1 and 3
2022-01-03 Added via layout json and found some bugs
2022-01-04 Renamed via file
2022-01-04 Further notes added to schematic about A0 being connected to user button
2022-01-04 Futher notes
2022-11-19 Fixed numpad issue
